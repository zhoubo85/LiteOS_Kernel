# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32F7XX_NUCLEO_144,ADAFRUIT_TFT_JOY_SD_ID802,LOS_STM32F746ZG
  c include: ..\..\example\include;..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m7;..\..\kernel\cmsis;..\..\platform\STM32F746ZG_NUCLEO;..\..\user;..\..\BSP\STM32F7xx\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\BSP\STM32F7xx\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\BSP\STM32F7xx\Drivers\BSP\STM32F7xx_Nucleo_144;..\..\BSP\STM32F7xx\Drivers\BSP\Components\Common;..\..\BSP\STM32F7xx\Inc;..\..\BSP\STM32F7xx\Src;..\..\BSP\STM32F7xx\Drivers\CMSIS\Include;..\..\subsys\net\LosCoAP\include;..\..\subsys\net\LosMIP\include;..\..\subsys\oclink\src;..\..\subsys\oclink\example
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m7
    ../../kernel/cpu/arm/cortex-m7/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/stm32f746zg
    ../../platform/STM32F746ZG_NUCLEO/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group BSP/STM32F7xx
    ../../BSP/STM32F7xx/Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
    ../../BSP/STM32F7xx/Src/: stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c system_stm32f7xx.c
    ../../BSP/STM32F7xx/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_tim.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_gpio.c stm32f7xx_ll_fmc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_spi.c
  group subsys/net/mip
    ../../subsys/net/LosMIP/core/: los_mip_arp.c los_mip_connect.c los_mip_dhcp.c los_mip_ethernet.c los_mip_icmp.c los_mip_inet.c los_mip_ipv4.c los_mip_netbuf.c los_mip_netif.c los_mip_socket.c los_mip_tcpip_core.c los_mip_udp.c los_mip_tcp.c los_mip_igmp.c
    ../../subsys/net/LosMIP/driver/: los_mip_ethif.c
    ../../subsys/net/LosMIP/sys/: los_mip_mem.c los_mip_osfunc.c
  group sybsys/net/loscoap
    ../../subsys/net/LosCoAP/src/: coap_core.c coap_os_liteos.c
  group subsys/oclink
    ../../subsys/oclink/src/: los_oclink.c
    ../../subsys/oclink/example/: los_oclink_demo.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../BSP/STM32F7xx/: startup_stm32f746xx.s
  group user
    ../../user/: main.c max7219_driver_func.c
